# Keil uVision project led 7 doan dem tang.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: led 7 doan dem tang +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    C:/hoc/8051/bai_tap/Library/Delay/: Delay.c
